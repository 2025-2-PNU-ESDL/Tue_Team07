<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\Tue_Team07_TermProject.ewp</path>
    </project>
    <batchBuild />
</workspace>
